# Keil uVision project ADC.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ADC
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\ECU_Engine_Control_Project\SWC;.\ECU_Engine_Control_Project\RTE;.\ECU_Engine_Control_Project\BSW\MCAL;.\ECU_Engine_Control_Project\BSW\ECU_Abstraction\IoHwAb
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group RTE
    ../../../Automative Embedded/Automative_Embedded/ECU_Engine_Control_Project/RTE/: Rte_TorqueControl.c Rte_TorqueControl.h
  group SWC
    ../../../Automative Embedded/Automative_Embedded/ECU_Engine_Control_Project/SWC/: Torque_Control.c Torque_Control.h
  group IoHwAb
    ../../../Automative Embedded/Automative_Embedded/ECU_Engine_Control_Project/BSW/ECU_Abstraction/IoHwAb/: IoHwAb_LoadSensor.c IoHwAb_LoadSensor.h IoHwAb_MotorDriver.c IoHwAb_MotorDriver.h IoHwAb_SpeedSensor.c IoHwAb_SpeedSensor.h IoHwAb_ThrottleSensor.c IoHwAb_ThrottleSensor.h IoHwAb_TorqueSensor.c IoHwAb_TorqueSensor.h
  group MCAL
    ./ECU_Engine_Control_Project/BSW/MCAL/: Adc.c Adc.h Std_Types.h
  group main
    ./: main.c
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0
